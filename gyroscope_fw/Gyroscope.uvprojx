# Keil uVision project Gyroscope.uvprojx, settings and files
target Gyroscope (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Gyroscope
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB
  c include: .\Inc;.\PeriphLib\CMSIS\Device\ST\STM32F1xx\Include;.\PeriphLib\STM32F1xx_HAL_Driver\Inc;.\PeriphLib\CMSIS\Include;.\Middlewares\FatFs\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./Src/: startup_stm32f103xb.s
  group CMSIS
    ./Src/: system_stm32f1xx.c
  group PeriphLib
    ./PeriphLib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group User
    ./Src/: LED.c Config.c GPIO.c I2C.c SPI.c USART.c main.c stm32f1xx_it.c l3g4200d.c SD.c Timers.c stm32f1xx_hal_msp.c processFunctions.c adc.c
